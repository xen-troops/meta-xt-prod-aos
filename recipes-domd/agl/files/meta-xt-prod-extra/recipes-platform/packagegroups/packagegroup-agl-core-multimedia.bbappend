RDEPENDS_${PN}_remove = "agl-audio-plugin"
