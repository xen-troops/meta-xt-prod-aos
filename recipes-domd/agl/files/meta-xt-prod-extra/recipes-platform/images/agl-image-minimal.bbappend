require inc/agl-image.inc

IMAGE_INSTALL_remove = " \
    kernel-module-pvrsrvkm \
    kmscube \
"
