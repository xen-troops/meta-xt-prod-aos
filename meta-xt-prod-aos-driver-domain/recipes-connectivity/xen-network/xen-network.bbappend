RDEPENDS_${PN}_remove = " \
    kernel-module-xt-masquerade \
"

