RENESAS_BSP_URL = "git://github.com/xen-troops/linux.git"

BRANCH = "v4.14/rcar-3.7-ctc"
SRCREV = "${AUTOREV}"
LINUX_VERSION = "4.14.75"
